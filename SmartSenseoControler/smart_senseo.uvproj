# Keil uVision project smart_senseo.uvproj, settings and files
target smart_senseo (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: smart_senseo
  AfterMake: fromelf --bin --output .\smart_senseo.bin .\smart_senseo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: PART_LM4F120H5QR TARGET_IS_BLIZZARD_RA1
  c include: ..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: smart_senseo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: Startup.s smart_senseo.c
  group Libraries
    ../../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
